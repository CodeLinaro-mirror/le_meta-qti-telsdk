# Install telux packages for SDK toolchain
TOOLCHAIN_TARGET_TASK:append += "${MLIBPREFIX}telux ${MLIBPREFIX}telux-lib"
