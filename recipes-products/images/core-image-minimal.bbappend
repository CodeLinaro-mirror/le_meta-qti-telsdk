# Install telux packages for SDK toolchain
TOOLCHAIN_TARGET_TASK:append:sa525m += "${MLIBPREFIX}telux ${MLIBPREFIX}telux-lib"
