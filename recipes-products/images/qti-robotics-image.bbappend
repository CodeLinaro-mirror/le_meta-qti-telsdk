# Install telux packages for SDK toolchain
TOOLCHAIN_TARGET_TASK:append:kalama += "telux telux-lib"
